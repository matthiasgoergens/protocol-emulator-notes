.SUBCKT dummy a
.ENDS
