.subckt ARRAY_3T_allthick_L45n
.ends
