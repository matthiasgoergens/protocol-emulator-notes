.subckt ARRAY6T
.ends
